# Keil uVision project ftp_client_demo.uvproj, settings and files
target ftp_client_demo_sram (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: ftp_client_demo_sram
  c flags: Optim=1
  c define: LM3S6965 USE_EK_LM3S6965 USE_FREERTOS
  c misc: --gnu
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\ti\devices\lm3s;..\..\..\..\common\ti\boards;..\..\..\..\common\ti\boards\common;..\..\..\..\common\ti\boards\ek_lm3s6965;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\keil\cortex_m3;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_tcp\drivers;..\..\..\..\..\cyclone_tcp\core;..\..\..\..\..\cyclone_tcp\ipv4;..\..\..\..\..\cyclone_tcp\ipv6;..\..\..\..\..\cyclone_tcp\dhcp;..\..\..\..\..\cyclone_tcp\dhcpv6;..\..\..\..\..\cyclone_tcp\std_services;..\..\..\..\..\cyclone_tcp\ftp;..\..\..\..\..\cyclone_tcp\http;..\..\..\..\..\cyclone_tcp\smtp;..\..\..\..\..\cyclone_tcp\icecast;..\..\..\..\..\cyclone_crypto;..\..\..\..\..\cyclone_ssl
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\lm3s6965_sram.sct
  group Demo Sources
    ./: startup_lm3s6965.s retarget.c
    ../src/: system_lm3s6965.c main.c debug.c
  group Demo Headers
    ../src/: tcp_ip_stack_config.h freertosconfig.h
  group Common Sources
    ../../../../../common/: endian.c os.c str.c
  group Common Headers
    ../../../../../common/: endian.h os.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c dns_client.c ping.c
    ../../../../../cyclone_tcp/drivers/: lm3s_eth.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h dns_client.h ping.h
    ../../../../../cyclone_tcp/drivers/: lm3s_eth.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/keil/cortex_m3/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/keil/cortex_m3/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group EK-LM3S6965 Sources
    ../../../../common/ti/boards/ek_lm3s6965/: rit128x96x4.c
  group EK-LM3S6965 Headers
    ../../../../common/ti/boards/ek_lm3s6965/: rit128x96x4.h
  group Stellaris Periph Driver Lib Sources
    ../../../../common/ti/devices/lm3s/driverlib/: adc.c can.c comp.c cpu.c epi.c flash.c gpio.c hibernate.c i2c.c i2s.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Stellaris Periph Driver Lib Headers
    ../../../../common/ti/devices/lm3s/driverlib/: adc.h can.h comp.h cpu.h epi.h flash.h gpio.h hibernate.h i2c.h i2s.h interrupt.h mpu.h pin_map.h pwm.h qei.h rom.h rom_map.h rtos_bindings.h ssi.h sysctl.h systick.h timer.h uart.h udma.h usb.h watchdog.h
target ftp_client_demo_flash (ARM-ADS)
  device: LM3S6965 Texas Instruments
  cpu: as above
  output: ftp_client_demo_flash
  c flags: Optim=1
  c define: LM3S6965 USE_EK_LM3S6965 USE_FREERTOS
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\lm3s6965_flash.sct

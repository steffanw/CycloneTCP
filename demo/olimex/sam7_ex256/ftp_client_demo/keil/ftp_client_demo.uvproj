# Keil uVision project ftp_client_demo.uvproj, settings and files
target ftp_client_demo_sram (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: ftp_client_demo_sram
  c flags: Optim=1
  c define: AT91SAM7X256 USE_SAM7_EX256 USE_FREERTOS
  c misc: --gnu
  c include: ..\src;..\..\..\..\common\atmel\devices\sam7x;..\..\..\..\common\olimex\boards\common;..\..\..\..\common\olimex\boards\sam7_ex256;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\keil\sam7;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_tcp\drivers;..\..\..\..\..\cyclone_tcp\core;..\..\..\..\..\cyclone_tcp\ipv4;..\..\..\..\..\cyclone_tcp\ipv6;..\..\..\..\..\cyclone_tcp\dhcp;..\..\..\..\..\cyclone_tcp\dhcpv6;..\..\..\..\..\cyclone_tcp\std_services;..\..\..\..\..\cyclone_tcp\ftp;..\..\..\..\..\cyclone_tcp\http;..\..\..\..\..\cyclone_tcp\smtp;..\..\..\..\..\cyclone_tcp\icecast;..\..\..\..\..\cyclone_crypto;..\..\..\..\..\cyclone_ssl
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: .\sam7x_sram.sct
  link misc: --entry resetHandler
  group Demo Sources
    ./: startup_sam7x.s retarget.c
    ../src/: system_sam7x.c main.c debug.c
  group Demo Headers
    ../src/: tcp_ip_stack_config.h freertosconfig.h
  group Common Sources
    ../../../../../common/: endian.c os.c str.c
  group Common Headers
    ../../../../../common/: endian.h os.h str.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.c tcp_ip_stack_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c dns_client.c ping.c
    ../../../../../cyclone_tcp/drivers/: sam7x_eth.c ksz8721.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_relay.c dhcpv6_common.c dhcpv6_debug.c
    ../../../../../cyclone_tcp/ftp/: ftp_client.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: tcp_ip_stack.h tcp_ip_stack_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h dns_client.h ping.h
    ../../../../../cyclone_tcp/drivers/: sam7x_eth.h ksz8721.h
    ../../../../../cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_relay.h dhcpv6_common.h dhcpv6_debug.h
    ../../../../../cyclone_tcp/ftp/: ftp_client.h
  group FreeRTOS Sources
    ../../../../common/freertos/portable/keil/sam7/: port.c portasm.s
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS Headers
    ../../../../common/freertos/portable/keil/sam7/: portmacro.h
    ../../../../common/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group SAM7-EX256 Sources
    ../../../../common/olimex/boards/common/: lcd.c
  group SAM7-EX256 Headers
    ../../../../common/olimex/boards/sam7_ex256/: sam7_ex256.h
    ../../../../common/olimex/boards/common/: lcd.h
target ftp_client_demo_flash (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: as above
  output: ftp_client_demo_flash
  c flags: Optim=1
  c define: AT91SAM7X256 USE_SAM7_EX256 USE_FREERTOS
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  scatter file: .\sam7x_flash.sct
  link misc: --entry resetHandler
